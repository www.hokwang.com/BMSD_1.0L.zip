Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: BMSD-1.0L.IFC
Time: 2026-07-29T07:10:25
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 201607 多功能皂閥-上組件
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 201607多功能皂閥-上桶身
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: M4螺帽-特殊 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD-感應器護蓋
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: TOTO CSD 動作板
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 四合一皂液活塞橡膠(3) 201510
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 多功能皂閥-泡沫出口件
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 控制盒外殼_TEST
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 皂液蓋_Default
In: Default Storey
PredefinedType: ELEMENT; Material: PP 單聚物

# IfcBuildingElementProxy: 鏡櫃用控制盒-牆面固定板
In: Default Storey
PredefinedType: ELEMENT; Material: AISI 304

# IfcBuildingElementProxy: 鏡櫃用控制盒-背板-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 鏡櫃用控制盒-閥體卡環-1_5t
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 鏡櫃給皂機-1.0L皂桶
In: Default Storey
PredefinedType: ELEMENT; Material: PE 低/中密度
